## boards/shields/handykeyswired/Kconfig.shield
```kconfig
config SHIELD_HANDYKEYSWIRED
    def_bool $(shields_list_contains,handykeyswired)
```
